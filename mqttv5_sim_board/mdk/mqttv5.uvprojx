# Keil uVision project mqttv5.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F460JETA HDSC
  pack: HDSC.HC32F460.1.0.12
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003FC) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mqttv5 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HC32F460,MQTTV5
  c include: ..\src;..\driver;..\libraries\core;..\libraries\device;..\libraries\hc32_ll_driver\inc;..\ioLibrary_Driver-3.2.0\Ethernet;..\ioLibrary_Driver-3.2.0\Ethernet\W5500;..\ioLibrary_Driver-3.2.0\Internet\DHCP;..\ioLibrary_Driver-3.2.0\Internet\DNS;..\mbedtls\include;..\mbedtls\library;..\mqtt\MQTTPacket\src;..\mqtt\MQTTPacket\src\V3;..\mqtt\MQTTPacket\src\V5;..\modbus\nmbs;..\modbus
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3c0
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\Objects\mqttv5.sct
  group src
    ../src/: loopback.c main.c v5log.c wiz_interface.c wiz_platform.c syscalls.c config.c task_w5500.c
  group driver
    ../driver/: crc.c flash.c led.c spi.c sysclk.c usart.c
  group mqtt
    ../mqtt/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    ../mqtt/MQTTPacket/src/V3/: MQTTFormat.c
    ../mqtt/MQTTPacket/src/V5/: MQTTProperties.c MQTTV5Format.c MQTTV5Packet.c
  group libraries
    ../libraries/device/: startup_hc32f460_armcc.s system_hc32f460.c
    ../libraries/hc32_ll_driver/: hc32_ll.c hc32_ll_adc.c hc32_ll_aes.c hc32_ll_aos.c hc32_ll_can.c hc32_ll_clk.c hc32_ll_cmp.c hc32_ll_crc.c hc32_ll_dbgc.c hc32_ll_dcu.c hc32_ll_dma.c hc32_ll_efm.c hc32_ll_emb.c hc32_ll_event_port.c hc32_ll_fcg.c hc32_ll_fcm.c hc32_ll_gpio.c hc32_ll_hash.c hc32_ll_i2c.c hc32_ll_i2s.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_keyscan.c hc32_ll_mpu.c hc32_ll_ots.c hc32_ll_pwc.c hc32_ll_qspi.c hc32_ll_rmu.c hc32_ll_rtc.c hc32_ll_sdioc.c hc32_ll_spi.c hc32_ll_sram.c hc32_ll_swdt.c hc32_ll_tmr0.c hc32_ll_tmr4.c hc32_ll_tmr6.c hc32_ll_tmra.c hc32_ll_trng.c hc32_ll_usart.c hc32_ll_usb.c hc32_ll_utility.c hc32_ll_wdt.c hc32f460_ll_interrupts_share.c
  group mbedtls
    ../mbedtls/library/: aes.c aesce.c aesni.c aria.c asn1parse.c asn1write.c base64.c bignum.c bignum_core.c bignum_mod.c bignum_mod_raw.c block_cipher.c camellia.c ccm.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c constant_time.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c ecp_curves_new.c entropy.c entropy_poll.c error.c gcm.c hkdf.c hmac_drbg.c lmots.c lms.c md.c md5.c memory_buffer_alloc.c mps_reader.c mps_trace.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_ecc.c pk_wrap.c pkcs5.c pkcs7.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_cipher.c psa_crypto_client.c psa_crypto_driver_wrappers_no_static.c psa_crypto_ecp.c psa_crypto_ffdh.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_pake.c psa_crypto_rsa.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c psa_util.c ripemd160.c rsa.c rsa_alt_helpers.c sha1.c sha3.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_client.c ssl_cookie.c ssl_debug_helpers.c ssl_msg.c ssl_ticket.c ssl_tls.c ssl_tls12_client.c ssl_tls12_server.c ssl_tls13_client.c ssl_tls13_generic.c ssl_tls13_keys.c ssl_tls13_server.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write.c x509write_crt.c x509write_csr.c
  group ioLibrary_Driver
    ../ioLibrary_Driver-3.2.0/Ethernet/: socket.c wizchip_conf.c
    ../ioLibrary_Driver-3.2.0/Ethernet/W5500/: w5500.c
    ../ioLibrary_Driver-3.2.0/Internet/DHCP/: dhcp.c
    ../ioLibrary_Driver-3.2.0/Internet/DNS/: dns.c
  group modbus
    ../modbus/: nanomodbus.c
    ../modbus/nmbs/: port.c
